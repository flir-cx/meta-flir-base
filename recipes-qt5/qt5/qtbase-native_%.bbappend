FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://dont-use-statx-system-call.patch"

