# IMAGE_INSTALL_remove = ""

IMAGE_INSTALL_append += " \
    hostapd \
    imx-gst1.0-plugin \
    rndisload \
"

#     firmware-redpine \
#