
SRC_URI = "git://github.com/analogdevicesinc/libiio.git;protocol=https;nobranch=1 \
           file://0001-python-Do-not-verify-whether-libiio-is-installed-whe.patch \
           "