# Removing dependency to "file" saves about 6M from rootfs. file is not needed.
DEPENDS_remove = "file"