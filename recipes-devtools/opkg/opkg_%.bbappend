FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-Do-not-remove-trailing-slash-on-root-folder.patch"
