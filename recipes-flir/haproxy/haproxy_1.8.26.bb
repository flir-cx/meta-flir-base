include haproxy.inc
PR = "r0"
SRC_URI[md5sum] = "67e0c11997c05826996dba80fdceef2c"
SRC_URI[sha256sum] = "e3c2a81b6f26dcb736a34ebb5f134d3251ceccf30386214655fa7ed6d3afa400"
