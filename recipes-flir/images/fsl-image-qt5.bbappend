# IMAGE_INSTALL_remove = ""

IMAGE_INSTALL_append += " \
    firmware-redpine \
    hostapd \
    imx-gst1.0-plugin \
    rndisload \
"
