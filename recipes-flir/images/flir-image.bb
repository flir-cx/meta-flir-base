include flir-image-${MACHINE}.inc
LICENSE = "CLOSED"
FLIR_ROOT_PASSWORD ?= ""

COMPATIBLE_MACHINE = "(evco|ec501|nitrogen6x|qemuarm|eoco|ec201|ec302|ec401w|ec701)"
