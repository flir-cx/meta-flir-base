FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Temporary-fix-for-kernel-paging-error-from-videorend.patch"

