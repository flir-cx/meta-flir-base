# Disable all features, since we don't need any of them
PACKAGECONFIG = ""

